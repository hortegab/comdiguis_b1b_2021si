options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Dtiming
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Dtiming
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '7'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Rb_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bit_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: bit_delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: h
  id: variable
  parameters:
    value: micodigo.filtroNyquist(Sps,ntaps)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: micodigo.rcos(Sps,ntaps,alpha)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: ([1]*Sps)
  states: {}
- name: h
  id: variable
  parameters:
    value: micodigo.rrcos(Sps,ntaps,alpha)
  states: {state: disabled}
- name: ntaps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: samp_rate_dac
  id: variable
  parameters:
    value: samp_rate*32
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Dtiming
    N: Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,1
    label0: T1 R1
    label1: T2 R2
    label2: Diagrama de Ojo
    label3: T4 R4
    label4: Timing
    num_tabs: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: '0'
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Dtiming
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: Menu@4:0,0,1,1
  states: {}
- name: b_PSD_f_0
  id: b_PSD_f
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '4e-6'
    gui_hint: Menu@1:1,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: bit_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/radiogis_director/MisGits/comdiguis_b1b_2021si/vivalavida
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radiogis_director/MisGits/comdiguis_b1b_2021si/enviado.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: fff
  states: {}
- name: micodigo
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nimport math\n\ndef filtroNyquist(Sps,ntaps):\n    k=np.linspace(-ntaps/2,ntaps/2-1,ntaps)\n    h=np.sinc(k/Sps)\n    return h\n\n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=filtroNyquist(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=np.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=np.amax(h)\n    return h/Amp\n    \n    \n #######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=filtroNyquist(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=np.amax(h)\n    return h/Amp\n\n"
  states: {}
- name: note_0
  id: note
  parameters:
    note: Capa Pre-canal
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Capa canal
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: PCM
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Mensaje
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Pre-pre-canal
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@2:0,0,1,1
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@2:0,1,1,1
    label1: despues del canal
    label2: despues del acoplamiento
    nconnections: '2'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Menu@1:1,0,1,1
    label1: T2
    label2: R2
    name: '"Espectro en dB"'
    nconnections: '2'
    type: float
    width1: '3'
    width2: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:0,0,1,1
    label1: T1
    label2: R1
    marker1: '0'
    marker2: '7'
    marker3: '7'
    nconnections: '3'
    size: '128'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    width3: '3'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: T2
    label2: R2
    label3: R2.a
    nconnections: '3'
    size: 32*Sps
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R-1
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T-1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R2.a
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R1.a
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: R2.a
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: R1.a
  states: {}

connections:
- [E3TRadio_bipolar_decisor_ff_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [E3TRadio_bipolar_decisor_ff_0, '0', virtual_sink_0_1, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_bipolar_decisor_ff_0, '0']
- [E3TRadio_diezma_ff_0, '0', virtual_sink_0_1_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [b_bipolar_to_unipolar_ff_0, '0', blocks_float_to_char_0, '0']
- [b_unipolar2bipolar_ff_0, '0', interp_fir_filter_xxx_0, '0']
- [b_unipolar2bipolar_ff_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_1, '0']
- [blocks_char_to_float_1, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', b_PSD_f_0, '0']
- [virtual_source_0_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_eye_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', b_EYE_Timing_f_0, '0']
- [virtual_source_0_0_1_0, '0', qtgui_eye_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
