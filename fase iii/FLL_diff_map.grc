options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Dtiming
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Dtiming
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: Sps-1
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Tablav)
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Tablav
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: math.log(M,2)
  states: {}
- name: f_d
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Desviacion de Frecuencia
    start: '0'
    step: 1400/100
    stop: '1400'
    value: '0'
  states: {}
- name: fd
  id: variable
  parameters:
    value: '1'
  states: {}
- name: h
  id: variable
  parameters:
    value: micodigo.filtroNyquist(Sps,ntaps)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: micodigo.rcos(Sps,ntaps,alpha)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: ([1]*Sps)
  states: {}
- name: h
  id: variable
  parameters:
    value: micodigo.rrcos(Sps,ntaps,alpha)
  states: {state: disabled}
- name: mapdirect
  id: variable
  parameters:
    value: coding.direct_map(Tablav)
  states: {}
- name: mapinverse
  id: variable
  parameters:
    value: coding.inverse_map(Tablav)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: sym_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: sym_delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '1'
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 5,0,1,1
    label0: T-2 R-2
    label1: T2 R2
    label2: Diagrama de Ojo
    label3: T-1 R-1
    label4: Timing
    label5: RF
    label6: Constelaciones
    label7: T0-R0
    num_tabs: '8'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: np.exp(math.pi/4*1j)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_d
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: b_Eye_Timing_c_0
  id: b_Eye_Timing_c
  parameters:
    AlphaLineas: '0.5'
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Dtiming
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagramm"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: Menu@4:0,0,1,1
  states: {}
- name: b_FLL_tunner2_0
  id: b_FLL_tunner2
  parameters:
    Constellation: Tablav
  states: {}
- name: b_demod_constelacion_cb_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Tablav
  states: {}
- name: b_diez_cc_0
  id: b_diez_cc
  parameters:
    M: Sps-Dtiming
    N: Sps
  states: {}
- name: b_u_M_PAM_bb_0
  id: b_u_M_PAM_bb
  parameters:
    M: M
  states: {}
- name: b_u_de_M_PAM_bb_0
  id: b_u_de_M_PAM_bb
  parameters:
    M: M
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: sym_delay
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: int(sym_delay*bps)
    type: float
  states: {}
- name: blocks_delay_1_0_0
  id: blocks_delay
  parameters:
    delay: sym_delay
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: coding
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy\nimport math\n#######################################################\n##        Done by Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n#######################################################\n##       Constellation map  identification           ##\n#######################################################                  \n# Constellation points are analyzed to determine the \n# the map used for ordering of the constellation points\ndef sum_modulus(a,b,modulus):\n    # realiza una suma de a y b en modulo modulus\n    return (a+b)%modulus\n\ndef angle_map(constellation_points):\n    # esta funcion entrega todos los angulos positivos entre 0 y 2pi\n    angles=numpy.angle(constellation_points)\n    return sum_modulus(angles, 2*math.pi, 2*math.pi)\n\ndef inverse_map(constellation_points):\n    M=len(constellation_points)\n    angles=angle_map(constellation_points)\n    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero\n    delta_angle= 2*math.pi/M     # angulo entre puntos\n    cod_inv=numpy.round(angles/delta_angle)\n    cod_inv=cod_inv.astype(numpy.int) #conversion a entero \n    return cod_inv\n\ndef direct_map(constellation_points):\n    M=len(constellation_points)\n    codinv=inverse_map(constellation_points)\n    coddirect=numpy.array([0]*M)\n    for j in range(M):\n        temp=numpy.where(codinv==j)\n        coddirect[j]=temp[0][0]\n    return coddirect\n\n\"\"\" # SECCION DE PRUEBAS DEL CODIGO\nimport gnuradio.digital as digital\nconstelacion=digital.constellation_8psk().points()\nprint(\"constelacion = \", constelacion)\nmapdirect=direct_map(constelacion)\nprint(\"codigo directo = \", mapdirect)\nmapinverse=inverse_map(constelacion)\nprint(\"codigo inverso = \", mapinverse)\n\"\"\"\n\n\n\n\n\n\n"
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: 'Tablav '
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: M
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: M
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: mapdirect
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: mapinverse
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: ccf
  states: {}
- name: micodigo
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nimport math\n\ndef filtroNyquist(Sps,ntaps):\n    k=np.linspace(-ntaps/2,ntaps/2-1,ntaps)\n    h=np.sinc(k/Sps)\n    return h\n\n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=filtroNyquist(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=np.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=np.amax(h)\n    return h/Amp\n    \n    \n #######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=filtroNyquist(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=np.amax(h)\n    return h/Amp\n\n"
  states: {}
- name: note_0
  id: note
  parameters:
    note: Capa Pre-canal
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Capa canal
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Capa Modulacion
  states: {}
- name: note_0_0_1_0
  id: note
  parameters:
    note: M-PAM
  states: {}
- name: note_0_0_1_0_0
  id: note
  parameters:
    note: Diff Coding
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@6:0,0,1,1
    label1: T1
    label2: R1
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@6:0,1,1,1
    label1: R2
    label2: R2.a
    marker1: '-1'
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style1: '1'
    style2: '1'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@2:0,0,1,1
    label1: T2.Re
    label2: T2.Im
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@2:0,1,1,1
    label1: R2.Re
    label2: R2.Im
    label3: R2.a.Re
    label4: R2.a.Im
    nconnections: '2'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Menu@1:1,0,1,1
    label1: T2
    label2: R2
    name: '"Espectro en dB"'
    nconnections: '2'
    type: complex
    width1: '3'
    width2: '3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: T2.Re
    label2: T2.Im
    label3: R2.Re
    label4: R2.Im
    label5: R2.a.Re
    label6: R2.a.Im
    nconnections: '3'
    size: 6*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@3:0,0,1,1
    label1: T-1
    label2: R-1
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rs
    stemplot: 'True'
    type: float
    ymax: '9'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:0,0,1,1
    label1: T-2
    label2: R-2
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rb
    stemplot: 'True'
    type: float
    ymax: '9'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@7:0,0,1,1
    label1: T0
    label2: R0
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rs
    stemplot: 'True'
    type: float
    ymax: '9'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T-2
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T-1
  states: {}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: virtual_sink_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: R-2
  states: {}
- name: virtual_sink_0_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: R-1
  states: {}
- name: virtual_sink_0_0_0_2_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R2.a
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: R2.a
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: T-1
  states: {}
- name: virtual_source_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: R-1
  states: {}
- name: virtual_source_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: R-2
  states: {}
- name: virtual_source_0_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: R0
  states: {}
- name: virtual_source_0_1_1_1
  id: virtual_source
  parameters:
    stream_id: T-2
  states: {}
- name: virtual_source_0_1_1_1_0
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', b_u_M_PAM_bb_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [b_FLL_tunner2_0, '0', b_demod_constelacion_cb_0, '0']
- [b_FLL_tunner2_0, '0', virtual_sink_0_1, '0']
- [b_demod_constelacion_cb_0, '0', digital_map_bb_0_0, '0']
- [b_demod_constelacion_cb_0, '0', virtual_sink_0_0_0_2_0_0, '0']
- [b_diez_cc_0, '0', b_FLL_tunner2_0, '0']
- [b_u_M_PAM_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [b_u_M_PAM_bb_0, '0', virtual_sink_0_0_0_1, '0']
- [b_u_de_M_PAM_bb_0, '0', blocks_null_sink_0, '0']
- [b_u_de_M_PAM_bb_0, '0', virtual_sink_0_0_0_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '2']
- [blocks_char_to_float_0, '0', blocks_delay_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_1_0_0, '1']
- [blocks_char_to_float_0_1, '0', blocks_delay_1_0, '0']
- [blocks_char_to_float_0_1_0, '0', blocks_delay_1_0_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_1_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_delay_1_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', b_diez_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0_1_0, '0']
- [blocks_multiply_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0_0_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', b_u_de_M_PAM_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0_0_2_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_0, '0', virtual_sink_0_0_0_1_0, '0']
- [digital_map_bb_0_0, '0', digital_diff_decoder_bb_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_eye_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', b_Eye_Timing_c_0, '0']
- [virtual_source_0_0_1_0, '0', qtgui_const_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', qtgui_eye_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [virtual_source_0_1, '0', qtgui_const_sink_x_0, '1']
- [virtual_source_0_1_1, '0', blocks_char_to_float_0, '0']
- [virtual_source_0_1_1_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0_1_1_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0_1_1_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [virtual_source_0_1_1_1, '0', blocks_char_to_float_0_1, '0']
- [virtual_source_0_1_1_1_0, '0', blocks_char_to_float_0_1_0, '0']

metadata:
  file_format: 1
